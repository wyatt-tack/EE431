v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {inv.sym} 30 0 0 0 {name=x1}
C {vsource.sym} -130 30 0 0 {name=V1 value=3 savecurrent=false}
C {vsource.sym} 10 -100 2 0 {name=V2 value=3 savecurrent=false}
